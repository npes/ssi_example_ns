# Keil uVision project ssi_Example_ns.uvprojx, settings and files
target APA102_SPI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ssi_Example_ns
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: .\projectFiles
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group SourceFiles
    ./projectFiles/driverlib/rvmdk/: driverlib.lib
    ./projectFiles/driverlib/: uart.c
    ./projectFiles/utils/: uartstdio.c
    ./projectFiles/: main.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
